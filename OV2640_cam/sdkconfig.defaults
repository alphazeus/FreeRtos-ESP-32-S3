## OV2640_cam/sdkconfig.defaults
```kconfig
CONFIG_IDF_TARGET="esp32s3"
CONFIG_ESPTOOLPY_FLASHSIZE_8MB=y
CONFIG_CAMERA_OV2640=y
CONFIG_SPIRAM=y
CONFIG_SPIRAM_MODE_OCT=y
```
